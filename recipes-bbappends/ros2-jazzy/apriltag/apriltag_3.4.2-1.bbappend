SRC_URI:remove = "file://0001-CMakeLists.txt-allow-to-set-PY_DEST.patch"
